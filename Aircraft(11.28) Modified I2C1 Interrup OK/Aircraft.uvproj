# Keil uVision project Aircraft.uvproj, settings and files
target Aircraft (ARM-ADS)
  device: STM32F051C6 STMicroelectronics
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0x8000000-0x8007FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: Aircraft
  c flags: Optim=1 uC99=1
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source Group
    ./: System.c startup_stm32f051.s main.c SPI.c ADC.c MPU6050.c RF_XN297.c FBM320.c I2CInquire.c
